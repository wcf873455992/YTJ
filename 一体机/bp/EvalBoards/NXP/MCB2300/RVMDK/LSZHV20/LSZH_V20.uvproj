# Keil uVision project LSZH_V20.uvproj, settings and files
target LSZH_V20_DEBUG (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LSZH_V20
  c flags: Optim=1
  c include: ..\BSP;..\..\IAR\BSP;..\..\IAR\Device\include;..\..\IAR\user\user_debug;..\..\IAR\user\user_flash;..\..\IAR\user\user_mem;..\..\IAR\user\User_Option;..\..\..\..\..\uC-CPU\ARM\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-II\Ports\ARM\Generic\RealView;..\..\..\..\..\uCOS-II\Source;..\..\IAR\user;..\..\IAR\BSP;..\..\..\..\..\uC-CPU;..\..\IAR\Device\tcpip\INCLUDE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\IAR\BSP\inchip.scf
  group APP
    ../../IAR/user/: main.c includes.h os_cfg.h
  group BSP
    ../BSP/: vectors.s init.s
    ../../IAR/BSP/: target.h target.c
  group Device
    ../../IAR/Device/HW/: hw.c
    ../../IAR/Device/IIC/: I2C0INT.c I2C1INT.c
    ../../IAR/Device/IIS/: dma.c i2s.c TMS320AIC23.c Use_Sound.c
    ../../IAR/Device/include/: CD22M3494.H dma.h hw.h I2C0INT.h I2C1INT.h I2S.h io.h PT2258.H RealTime.h SC16IS752.h TMS320AIC23.h uart.h use_sound.h
    ../../IAR/Device/IO/: io.c
    ../../IAR/Device/PT2258/: CD22M3494.C PT2258.C
    ../../IAR/Device/Realtime/: RealTime.c
    ../../IAR/Device/SPI/: SC16IS752.c
    ../../IAR/Device/tcpip/API/: os_api.c
    ../../IAR/Device/tcpip/ARP/: ARP.C
    ../../IAR/Device/tcpip/ETHERNET/: Ethernet.c
    ../../IAR/Device/tcpip/HARDWARE/: Hardware_int.c
    ../../IAR/Device/tcpip/INCLUDE/: ARP.H cfg_net.h ETHERNET.H HARDWARE.H ICMP.H IP.H LPC23XX_ADD_R.H os_api.h TCP.H Udp.h UTILITS.H zlg_socket.h
    ../../IAR/Device/tcpip/IP/: IP.C
    ../../IAR/Device/tcpip/PING/: ICMP.C
    ../../IAR/Device/tcpip/UDP/: Udp.c
    ../../IAR/Device/UART/: uart.c
  group uCOS_CPU
    ../../../../../uC-CPU/: cpu_def.h
    ../../../../../uC-CPU/ARM/RealView/: cpu.h cpu_a.s
    ../../../../../uCOS-II/Ports/ARM/Generic/RealView/: os_cpu_a.asm os_cpu.h
  group uCOS_LIB
    ../../../../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOSII
    ../../../../../uCOS-II/Ports/ARM/Generic/RealView/: os_cpu_c.c os_dbg.c
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group User
    ../../IAR/user/user_debug/: user_debug.c
    ../../IAR/user/user_flash/: LP2368_FLASH.c
    ../../IAR/user/user_mem/: user_mem.c
    ../../IAR/user/User_Option/: PelcoD.c Use_key.c User_DW.c User_on_msg.c User_option.c User_power.c User_table.c User_TB.c User_udp.c User_XCOM.c
