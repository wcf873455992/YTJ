<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\user\includes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\os_cfg.h</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\..\BSP\cstartup.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\LPC2378_Flash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\LPC23xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\LSZH_V20_Relase.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\target.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\target.h</name>
    </file>
  </group>
  <group>
    <name>Device</name>
    <group>
      <name>Api</name>
      <file>
        <name>$PROJ_DIR$\..\Device\tcpip\API\os_api.c</name>
      </file>
    </group>
    <group>
      <name>TCP/IP</name>
      <group>
        <name>ARP</name>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\ARP\ARP.C</name>
        </file>
      </group>
      <group>
        <name>HARDWARE</name>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\ETHERNET\Ethernet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\HARDWARE\Hardware_int.c</name>
        </file>
      </group>
      <group>
        <name>ICMP</name>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\PING\ICMP.C</name>
        </file>
      </group>
      <group>
        <name>IP</name>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\IP\IP.C</name>
        </file>
      </group>
      <group>
        <name>UDP</name>
        <file>
          <name>$PROJ_DIR$\..\Device\tcpip\UDP\Udp.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Device\PT2258\CD22M3494.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIS\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\HW\hw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIC\I2C0INT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIC\I2C1INT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIS\i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IO\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\PT2258\PT2258.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\Realtime\RealTime.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\SPI\SC16IS752.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIS\TMS320AIC23.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\UART\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\IIS\Use_Sound.c</name>
    </file>
  </group>
  <group>
    <name>uC/CPU</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\ARM\IAR\cpu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\ARM\IAR\cpu_a.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\cpu_def.h</name>
    </file>
  </group>
  <group>
    <name>uC/LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_def.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_mem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_str.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_str.h</name>
    </file>
  </group>
  <group>
    <name>uCOS-II</name>
    <group>
      <name>Port</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\os_cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\os_cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\os_dbg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\os_dcc.c</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\ucos_ii.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\user\user_flash\LP2368_FLASH.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\user_flash\LP2368_FLASH.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\Lszh_hardware.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\lszh_msg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\PelcoD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\PelcoD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\Use_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\Use_key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\user_debug\user_debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\user_debug\user_debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_DW.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_DW.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\user_mem\user_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\user_mem\User_mem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_on_msg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\user_on_msg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_option.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_option.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_power.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_power.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_Run.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_table.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_table.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_TB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_TB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_udp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_udp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_XCOM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\User_Option\User_XCOM.h</name>
    </file>
  </group>
</project>


