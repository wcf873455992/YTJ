<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LSZH_V20_FLASH.ewp</path>
  </project>
  <batchBuild/>
</workspace>


